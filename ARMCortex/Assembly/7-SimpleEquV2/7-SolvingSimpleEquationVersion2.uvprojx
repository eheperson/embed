# Keil uVision project 7-SolvingSimpleEquationVersion2.uvprojx, settings and files
target Cortex-M4 (6140000::V6.14::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: 7-SolvingSimpleEquationVersion2
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ./: main.s
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2
